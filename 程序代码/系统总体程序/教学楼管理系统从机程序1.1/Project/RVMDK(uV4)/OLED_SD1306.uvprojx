# Keil uVision project OLED_SD1306.uvprojx, settings and files
target OLED_SD1306 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED_SD1306 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\src;..\..\Libraries\inc;..\..\User\light;..\..\User;..\..\User\dht11;..\..\User\AS608;..\..\User\USART3;..\..\User\sys;..\..\User\KEY;..\..\User\TIMER;..\..\User\Advance_TIM;..\..\User\adc;..\..\User\Led;..\..\User\IR_record
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h OLED_I2C.c delay.c
    ../../User/light/: light.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/AS608/: as608.c
    ../../User/USART3/: usart3.c
    ../../User/sys/: sys.c
    ../../User/KEY/: key.c
    ../../User/TIMER/: timer.c
    ../../User/Advance_TIM/: bsp_Advance_tim.c
    ../../User/adc/: bsp_adc.c
    ../../User/Led/: bsp_led.c
    ../../User/IR_record/: IR_record.c
  group DOC
    ../../Doc/: Readme.txt
software components: CMSIS:CORE 4.3.0

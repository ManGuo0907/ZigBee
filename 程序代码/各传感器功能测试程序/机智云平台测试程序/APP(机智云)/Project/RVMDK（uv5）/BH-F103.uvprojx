# Keil uVision project BH-F103.uvprojx, settings and files
target USART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\User\timer;..\..\User\delay;..\..\User\KEY;..\..\User\KEY2;..\..\User\sys;..\..\User\USART1;..\..\User\usart;..\..\User\Gizwits;..\..\User\Utils;..\..\User\rx_data;..\..\User\usart2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c
    ../../User/Led/: bsp_led.c
    ../../User/timer/: timer.c
    ../../User/KEY/: key.c
    ../../User/delay/: delay.c
    ../../User/KEY2/: bsp_key.c
    ../../User/sys/: sys.c
    ../../User/USART1/: bsp_usart1.c
    ../../User/usart/: bsp_usart.c
    ../../User/rx_data/: rx_data_queue.c
    ../../User/usart2/: bsp_usart2.c
  group DOC
    ../../Doc/: readme.txt
  group Gizwits
    ../../User/Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../../User/Utils/: common.c dataPointTools.c ringbuffer.c

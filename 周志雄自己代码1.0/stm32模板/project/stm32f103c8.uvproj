# Keil uVision project stm32f103c8.uvproj, settings and files
target stm32f103c8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103c8 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\CMSIS;..\hardware\EXTI;..\hardware\iwdg;..\hardware\jdq;..\hardware\KEY;..\hardware\LED;..\hardware\sys;..\hardware\TIMER;..\hardware\usart;..\Lib\inc;..\Lib\src;..\Startup;..\User;..\hardware\RTC;..\hardware\beep;..\hardware\door;..\hardware\dht11;..\hardware\adc;..\Gizwits;..\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_adc.c stm32f10x_dma.c
  group hardware
    ../hardware/usart/: delay.c usart.c usart3.c usart2.c
    ../hardware/EXTI/: exti.c
    ../hardware/iwdg/: iwdg.c
    ../hardware/jdq/: jdq.c
    ../hardware/KEY/: key.c
    ../hardware/LED/: led.c
    ../hardware/sys/: sys.c
    ../hardware/TIMER/: timer.c
    ../hardware/RTC/: rtc.c
    ../hardware/beep/: beep.c
    ../hardware/door/: door.c
    ../hardware/dht11/: DHT11.c
    ../hardware/adc/: adcx.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
